# Keil uVision project audiomark_app.Release+MPS3-Corstone-300.uvprojx, settings and files
target Release+MPS3-Corstone-300 (6190000::V6.19::.\ARMCLANG6.19)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: audiomrk
  c flags: Optim=5 v6Lang=6 v6LangP=3
  c define: OS_SUPPORT_CUSTOM
  c misc: -ffast-math
  c include: .;../../lib/speexdsp/include;../../lib/speexdsp/libspeexdsp;../../ports/arm/;../../ports/arm/libs/CMSIS-NN/Include;../../src/;../../lib/speexdsp/include/speex/;../../lib/speexdsp/
  asm include: as above
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --info=summarysizes --info=sizes --info=totals --info=unused --info=veneers
  group App
    ../../src/: ee_audiomark.c ee_abf_f32_tables.c ee_nn_tables.c
    ../../: main.c
    ./: platform_init.c
  group AudioMarkCore
    ../../src/: ee_abf_f32.c ee_anr_f32.c ee_kws.c ee_mfcc_f32.c ee_aec_f32.c ee_mfcc_f32_tables.c
    ../../ports/arm/: th_api.c
  group Printf retarget
    ./: stdout_USART.c
  group Libspeex
    ../../lib/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c kiss_fft.c kiss_fftr.c mdf.c preprocess.c resample.c scal.c smallft.c
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, CMSIS:NN Lib 4.0.0, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.1.0, Utilities:perf_counter:Core 1.9.9a, Compiler:I/O:STDOUT 1.2.0
