# Keil uVision project audiomark_app.Release+Ethos-MPS3-Corstone-310.uvprojx, settings and files
target Release+Ethos-MPS3-Corstone-310 (6210000::V6.21::ARMCLANG)
  device: SSE-310-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.1.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: audiomark_app.axf
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6
  c define: FLOATING_POINT USE_CMSIS_DSP  TF_INTERPRETER OS_SUPPORT_CUSTOM ETHOSU55
  c misc: -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -include "RTE_Components.h"
  c include: ../../../src;../../../ports/arm;../../../ports/arm/include;.;../../../ports/arm/
  asm define: TF_INTERPRETER OS_SUPPORT_CUSTOM ETHOSU55
  asm include: as above
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: ../linker/SSE-310-MPS3/fvp_sse310_mps3_ns.sct
  link misc: --entry=Reset_Handler --info summarysizes --diag_suppress=L6314W --diag_suppress=L6329W --diag_suppress=L6439W
  group App
    ../../../src/: ee_audiomark.c
    ../../../: main.c
    ../: platform_init.c
  group AudioMarkCore
    ../../../src/: ee_abf_f32.c ee_abf_f32_tables.c ee_aec_f32.c ee_anr_f32.c ee_kws.c ee_mfcc_f32.c ee_mfcc_f32_tables.c ee_nn_tables.c
    ../../../ports/arm/: th_api.c
  group AudioMark-TensorflowInterpreter
    ../: arm_ethosu_npu_init.cpp
    ../../../ports/arm/: ds_cnn_model.cpp ds_cnn_s_quantized_U55_256_vela.tflite.cpp run_ethosu.cpp
  group Printf retarget
    ../: stdout_USART.c
  group Libspeex
    ../../../lib/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c mdf.c preprocess.c resample.c scal.c smallft.c
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, CMSIS:NN Lib 4.1.0, Device:Definition 1.1.0, Device:Startup 1.0.1, MCU Driver HAL:DMA350 1.0.0, ML Eval Kit:Common:API 1.0.0, ML Eval Kit:Common:Log 1.0.0, ML Eval Kit:Common:Math 1.0.0, Native Driver:DMA350 Remap:Custom 1.0.0, Native Driver:DMA350 Remap:SSE-310 Remap 1.0.0, Native Driver:DMA350 1.1.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Machine Learning:NPU Support:Ethos-U Driver 1.22.8, Utilities:perf_counter:Core 1.9.11, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.22.8, Data Processing:Math:gemmlowp fixed-point 1.22.8, Data Processing:Math:kissfft 1.22.8, Data Processing:Math:ruy 1.22.8, Machine Learning:TensorFlow:Kernel Utils 1.22.8, Machine Learning:TensorFlow:Kernel 1.22.8
