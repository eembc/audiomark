# Keil uVision project audiomark_app.Release+Ethos-MPS3-Corstone-300.uvprojx, settings and files
target Release+Ethos-MPS3-Corstone-300 (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: audiomark_app.axf
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6
  c define: FLOATING_POINT USE_CMSIS_DSP  TF_INTERPRETER OS_SUPPORT_CUSTOM ETHOSU55
  c misc: -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -include "RTE_Components.h"
  c include: ../../../src;../../../ports/arm;../../../ports/arm/include;.;../../../ports/arm/
  asm define: TF_INTERPRETER OS_SUPPORT_CUSTOM ETHOSU55
  asm include: as above
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: ../linker/SSE-300-MPS3/EthosU_fvp_sse300_mps3_ns.sct
  link misc: --entry=Reset_Handler --info summarysizes --diag_suppress=L6314W --diag_suppress=L6329W --diag_suppress=L6439W
  group App
    ../../../src/: ee_audiomark.c
    ../../../: main.c
    ../: platform_init.c
  group AudioMarkCore
    ../../../src/: ee_abf_f32.c ee_abf_f32_tables.c ee_aec_f32.c ee_anr_f32.c ee_kws.c ee_mfcc_f32.c ee_mfcc_f32_tables.c ee_nn_tables.c
    ../../../ports/arm/: th_api.c
  group AudioMark-TensorflowInterpreter
    ../../../ports/arm/: th_api.c ds_cnn_model.cpp ds_cnn_s_quantized_U55_128_vela.tflite.cpp run_ethosu.cpp
    ../: arm_ethosu_npu_init.cpp
  group Printf retarget
    ../: stdout_USART.c
  group Libspeex
    ../../../lib/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c mdf.c preprocess.c resample.c scal.c smallft.c
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, CMSIS:NN Lib 4.1.0, Device:Definition 1.2.0, Device:Startup 1.2.0, ML Eval Kit:Common:API 1.0.0, ML Eval Kit:Common:Log 1.0.0, ML Eval Kit:Common:Math 1.0.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.1.0, Machine Learning:NPU Support:Ethos-U Driver 1.22.8, Utilities:perf_counter:Core 1.9.11, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.22.8, Data Processing:Math:gemmlowp fixed-point 1.22.8, Data Processing:Math:kissfft 1.22.8, Data Processing:Math:ruy 1.22.8, Machine Learning:TensorFlow:Kernel Utils 1.22.8, Machine Learning:TensorFlow:Kernel 1.22.8
