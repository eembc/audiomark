# Keil uVision project EEMBC_AUDIOMARK.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EEMBC_AUDIOMARK
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: FIXED_POINT HAVE_CONFIG_H DISABLE_WARNINGS DISABLE_NOTIFICATIONS PLATFORM_ARCH_32BIT
  c include: ..\..\components\xiph\speexdsp\include\speex;..\..\components\xiph\speexdsp\libspeexdsp;..\..\components\xiph\speexdsp;..\..\libraries\DSP\Include;..\..\application_demo\debug_data; ..\..\components\xiph\speexdsp\include; ..\..\application_demo
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Source Group 1
    ../../components/arm/audio_beamformer/src/: arm_beamformer_f32.c arm_beamformer_process_f32.c arm_beamformer_tables_f32.c
    ../../components/xiph/echo_canceller/src/: xiph_aec.c
    ../../components/xiph/preprocess/src/: xiph_anr.c
    ../../components/xiph/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c kiss_fft.c kiss_fftr.c mdf.c preprocess.c resample.c scal.c smallft.c arm_libspeex_kernels.c
    ../../application_demo/: main.c audiomark.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
